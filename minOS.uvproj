# Keil uVision project minOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: minOS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.asm os.c tasks.c os.h LCD1602.h LCD1602.c minlib.c minlib.h
    ../../c51v952/C51/LIB/: C51S.LIB
